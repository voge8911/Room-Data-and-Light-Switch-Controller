# Keil uVision project Final_Project.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final_Project
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: PIR.c PIR.h ServoPWM.c ServoPWM.h main.c LCDLab.c LCD.h Light_Intensity_PWM.h Light_Intensity_PWM.c Temp_Light_Sensor.c Temp_Light_Sensor.h PWM.c PWM.h pushbutton.c pushbutton.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
